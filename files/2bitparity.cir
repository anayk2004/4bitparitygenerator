* D:\esim\2bitparity\2bitparity.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 11/06/24 19:57:35

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  Net-_SC10-Pad3_ Net-_SC2-Pad2_ Net-_SC5-Pad2_ Net-_SC4-Pad2_ Net-_SC9-Pad2_ Net-_SC12-Pad2_ Net-_SC13-Pad1_ Net-_SC1-Pad2_ PORT
scmode1  SKY130mode
SC3  Net-_SC1-Pad1_ GND Net-_SC10-Pad3_ ? sky130_fd_pr__pfet_01v8
SC7  Net-_SC6-Pad1_ GND Net-_SC10-Pad3_ ? sky130_fd_pr__pfet_01v8
SC10  Net-_SC10-Pad1_ GND Net-_SC10-Pad3_ ? sky130_fd_pr__pfet_01v8
SC13  Net-_SC13-Pad1_ GND Net-_SC10-Pad3_ ? sky130_fd_pr__pfet_01v8
SC1  Net-_SC1-Pad1_ Net-_SC1-Pad2_ Net-_SC1-Pad3_ ? sky130_fd_pr__nfet_01v8
SC2  Net-_SC1-Pad3_ Net-_SC2-Pad2_ Net-_SC2-Pad3_ ? sky130_fd_pr__nfet_01v8
SC5  Net-_SC2-Pad3_ Net-_SC5-Pad2_ Net-_SC4-Pad1_ ? sky130_fd_pr__nfet_01v8
SC4  Net-_SC4-Pad1_ Net-_SC4-Pad2_ Net-_SC1-Pad1_ ? sky130_fd_pr__nfet_01v8
SC6  Net-_SC6-Pad1_ Net-_SC1-Pad1_ GND ? sky130_fd_pr__nfet_01v8
SC8  Net-_SC10-Pad1_ Net-_SC6-Pad1_ ? ? sky130_fd_pr__nfet_01v8
SC9  ? Net-_SC9-Pad2_ Net-_SC11-Pad1_ ? sky130_fd_pr__nfet_01v8
SC11  Net-_SC11-Pad1_ Net-_SC1-Pad1_ Net-_SC11-Pad3_ ? sky130_fd_pr__nfet_01v8
SC12  Net-_SC11-Pad3_ Net-_SC12-Pad2_ Net-_SC10-Pad1_ ? sky130_fd_pr__nfet_01v8
SC14  Net-_SC13-Pad1_ Net-_SC10-Pad1_ GND ? sky130_fd_pr__nfet_01v8

.end
